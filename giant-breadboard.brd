File: giant-breadboard.brd (EAGLE design)
At the start: 457.2 x 393.7 mm, 0 parts

Commit message: Rotated power rail holes to make assembly easier.
Other:
- outline, holes or cut-outs redrawn
